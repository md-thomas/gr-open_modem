options:
  parameters:
    author: mdthomas
    category: '[open_modem]'
    comment: Same TX/RX/ACK loop as open_modem_loopback.grc, but with a real noisy channel in between (analog.noise_source_f + blocks.add_ff, not the stock channels_channel_model, which is complex-only and doesn't fit this real-valued audio PHY) instead of a clean direct connection. Raise --noise-sigma from the command line to watch delivery degrade, retries kick in, and eventually delivery_failed fire - the live, GNU-Radio-native counterpart to apps/margin_sweep.py's offline noise sweep.
    description: open_modem TX/RX loopback with an adjustable noisy channel
    generate_options: no_gui
    id: open_modem_noisy_loopback
    output_language: python
    title: open_modem Loopback with a Noisy Channel
  states: {}

blocks:
- name: ack_responder_0
  id: open_modem_ack_responder
  parameters:
    comment: Turns open_modem_rx_0's ack_needed into a real ACK burst, fed back through the SAME noisy channel (pdu_to_stream_0/the adder) as open_modem_tx_0's own audio_out/ptt - an ACK can be lost to noise too, which is exactly what should drive open_modem_tx_0's retries once noise_sigma is raised high enough. Shares the mode_id parameter below with open_modem_tx_0/open_modem_rx_0, not its own copy.
    dst_id: ALL
    fec_preset: ''
    mode_id: mode_id
    port: mic
    station_id: K0MDT
    tx_level: '0.7'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    comment: Gaussian noise added to the channel - the standard deviation is noise_sigma, settable from the command line with --noise-sigma.
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: The noisy channel itself - sums the clean audio burst stream with the Gaussian noise stream, continuously (including the silence pdu_to_stream_0 outputs between bursts, which is itself realistic - a real channel's noise floor is never actually absent).
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Decoded frames (and bursts heard but not decoded, as noise increases) print here - status, mode, snr_db, quality, and for 'ok' also src_id/dst_id/seq + the payload bytes.
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: key/unkey events print here, from both open_modem_tx_0 (data bursts, including retries) and ack_responder_0 (ACK bursts).
  states: {}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters:
    comment: Fires if ack_max_retries is exceeded with no ACK heard back - unlike open_modem_loopback.grc's clean channel, this is genuinely expected to happen once noise_sigma is high enough.
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Sends a fixed test message through the TX chain every 4 s - no GUI message box since this flowgraph has no window (generate_options no_gui) to put one in.
    msg: pmt.intern("hello through a noisy channel")
    period: '4000'
  states: {}
- name: mode_id
  id: parameter
  parameters:
    comment: The one Waveform Mode under test - open_modem_tx_0, open_modem_rx_0 and ack_responder_0 all reference this single value instead of each carrying their own, so changing mode here changes it everywhere at once. Found the hard way - TX and RX used to be set independently, and a station only ever decodes its own mode cleanly (even the preamble is modulated differently per mode, so a mismatch fails outright, not just more often under noise). See open_modem_open_modem_tx's own dropdown for what each number is (0-2 fit the mic port; 3-5 need the data port).
    short_id: m
    type: intx
    value: '3'
  states: {}
- name: noise_sigma
  id: parameter
  parameters:
    comment: Noise standard deviation added to the channel. Burst peak is about 0.7 (open_modem_tx_0's tx_level), open squelch hiss on a real radio is roughly in the 0.05-0.2 range (see open_wave/RADIO_SETUP.md's level_meter targets) - start small and raise it past where delivery starts failing.
    short_id: n
    type: eng_float
    value: '0.9'
  states: {}
- name: open_modem_rx_0
  id: open_modem_open_modem_rx
  parameters:
    comment: Wrapped in a list because open_modem_rx can try several candidate modes per burst in general - here it's a single-element list referencing the shared mode_id parameter below, so it can never drift out of sync with open_modem_tx_0/ack_responder_0 the way two independently-set values could (and did).
    fec_preset: ''
    max_burst_s: '6.0'
    mode_ids: '[mode_id]'
    port: mic
    sample_rate: '48000'
    threshold: '0.4'
  states: {}
- name: open_modem_tx_0
  id: open_modem_open_modem_tx
  parameters:
    ack_max_retries: '3'
    ack_requested: 'True'
    ack_timeout_s: '2.0'
    dst_id: ALL
    fec_preset: ''
    lead_in_s: '0.1'
    mode_id: mode_id
    port: mic
    station_id: K0MDT
    tail_s: '0.02'
    tx_level: '0.7'
  states: {}
- name: pdu_to_stream_0
  id: open_modem_pdu_to_stream
  parameters:
    comment: Drains open_modem_tx_0's (and ack_responder_0's) audio_out PDUs into a float stream a work() call at a time - see open_modem_loopback.grc's own top-level comment for why not the stock PDU to Tagged Stream block.
  states: {}

connections:
- [ack_responder_0, audio_out, pdu_to_stream_0, pdus]
- [ack_responder_0, ptt, blocks_message_debug_1, print]
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', open_modem_rx_0, '0']
- [blocks_message_strobe_0, strobe, open_modem_tx_0, pdu_in]
- [open_modem_rx_0, ack_needed, ack_responder_0, ack_needed]
- [open_modem_rx_0, ack_received, open_modem_tx_0, ack_received]
- [open_modem_rx_0, pdu_out, blocks_message_debug_0, print]
- [open_modem_tx_0, audio_out, pdu_to_stream_0, pdus]
- [open_modem_tx_0, delivery_failed, blocks_message_debug_2, print]
- [open_modem_tx_0, ptt, blocks_message_debug_1, print]
- [pdu_to_stream_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
