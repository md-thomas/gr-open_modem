options:
  parameters:
    author: mdthomas
    category: '[open_modem]'
    comment: One simulated station - run this TWICE (two separate processes, same machine or different ones) to simulate a real two-way exchange with no hardware at all. Each instance's Audio Sink/Source use ALSA's 'pulse' device, redirected per-process to a PipeWire/PulseAudio null-sink pair (no root/kernel module needed, unlike snd-aloop) via PULSE_SINK/PULSE_SOURCE environment variables set before launch - see examples/README.md for the exact pactl setup and the two launch commands. Each station injects Gaussian noise into its OWN outgoing audio before it leaves this process (a live 'Noise sigma' slider - a real channel model, not a placeholder), so the two directions can be noisy independently, same as a real asymmetric radio link. Type into Send, watch Received - the GUI equivalent of typing into ota_station.py or radio_send.py/radio_listen.py from a terminal.
    description: One simulated open_modem station - run two instances to talk to each other, no hardware needed
    generate_options: qt_gui
    id: open_modem_station_sim
    output_language: python
    title: open_modem Simulated Station
  states: {}

blocks:
- name: noise_sigma
  id: variable_qtgui_range
  parameters:
    comment: This station's OWN outgoing noise - the other station's incoming link quality depends only on this slider, not on anything set at the far end.
    gui_hint: 0,0,1,2
    label: Noise sigma (this station's outgoing link)
    start: '0'
    step: '0.02'
    stop: '2.0'
    value: '0.2'
  states: {}
- name: ack_responder_0
  id: open_modem_ack_responder
  parameters:
    comment: Shares the SAME pdu_to_stream_0/noisy channel/Audio Sink as open_modem_tx_0 - an ACK goes out over the exact same simulated link.
    dst_id: dst_id
    fec_preset: ''
    mode_id: mode_id
    port: mic
    station_id: station_id
    tx_level: tx_level
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    comment: This station's own channel model, applied to its OWN outgoing audio before it ever leaves this process.
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Device is always 'pulse' here - which actual PipeWire/PulseAudio sink that reaches is set per-process by the PULSE_SINK environment variable at launch, not by anything in this flowgraph. See examples/README.md.
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Device is always 'pulse' here too - redirected per-process via PULSE_SOURCE at launch to the OTHER station's outgoing link (its monitor), not this station's own.
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: key/unkey events from open_modem_tx_0/ack_responder_0 - informational only, no real PTT hardware in a simulation.
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: Fires if ack_max_retries is exceeded with no ACK heard back.
  states: {}
- name: dst_id
  id: parameter
  parameters:
    short_id: d
    type: str
    value: ALL
  states: {}
- name: mode_id
  id: parameter
  parameters:
    comment: Both stations must use the same mode - there's nothing here to negotiate it automatically.
    short_id: m
    type: intx
    value: '1'
  states: {}
- name: open_modem_rx_0
  id: open_modem_open_modem_rx
  parameters:
    comment: mode_ids left at [] (auto, try every mode the port fits), not pinned to [mode_id] - this station should be able to hear a peer on a different mode than its own TX default, same reasoning as open_modem_ht.grc.
    fec_preset: ''
    max_burst_s: '6.0'
    mode_ids: '[]'
    port: mic
    sample_rate: '48000'
    threshold: '0.4'
  states: {}
- name: open_modem_tx_0
  id: open_modem_open_modem_tx
  parameters:
    ack_max_retries: '3'
    ack_requested: 'True'
    ack_timeout_s: '2.0'
    dst_id: dst_id
    fec_preset: ''
    lead_in_s: '0.25'
    mode_id: mode_id
    port: mic
    station_id: station_id
    tail_s: '0.02'
    tx_level: tx_level
  states: {}
- name: pdu_to_stream_0
  id: open_modem_pdu_to_stream
  parameters:
    comment: Drains open_modem_tx_0's (and ack_responder_0's) audio_out PDUs into a float stream a work() call at a time - not the stock PDU to Tagged Stream block, same reason as every other example here (see TODO.md).
    dtype: float
  states: {}
- name: pdu_to_text_0
  id: open_modem_pdu_to_text
  parameters:
    comment: Formats open_modem_rx_0's decoded-frame PDU into one readable line for the Received box, which wants a plain string, not a raw PDU.
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Type a message and press Enter to transmit it.
    gui_hint: 1,0,1,2
    is_pair: 'False'
    label: Send
    type: string
    value: '""'
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    comment: Read-only - shows the most recent decoded message (or heard-but-undecoded note), fed via its 'val' port, never typed into.
    gui_hint: 2,0,1,2
    is_pair: 'False'
    label: Received
    type: string
    value: '""'
  states: {}
- name: pdu_to_stream_1
  id: open_modem_pdu_to_stream
  parameters:
    comment: Converts open_modem_rx_0's symbols_out PDU (demodulated complex symbols, truncated to the real frame) into a complex stream for the Constellation Sink - not the stock PDU to Tagged Stream block, same buffer-ceiling reason as open_modem_constellation.grc.
    dtype: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Required here, not optional - see open_modem_constellation.grc's own comment on this block (TODO.md has the full story - 168 million samples in 5 seconds without it).
    samples_per_second: '9600'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Each point is one demodulated symbol from a burst THIS station received - i.e. what the far end actually sent, degraded by whatever noise_sigma the far end has set on its own outgoing link (not this station's own slider above).
    grid: 'True'
    gui_hint: 3,0,1,2
    size: '1024'
    type: complex
  states: {}
- name: station_id
  id: parameter
  parameters:
    short_id: s
    type: str
    value: K0MDT-1
  states: {}
- name: tx_level
  id: parameter
  parameters:
    short_id: l
    type: eng_float
    value: '0.7'
  states: {}

connections:
- [ack_responder_0, audio_out, pdu_to_stream_0, pdus]
- [ack_responder_0, ptt, blocks_message_debug_0, print]
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', open_modem_rx_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [open_modem_rx_0, ack_needed, ack_responder_0, ack_needed]
- [open_modem_rx_0, ack_received, open_modem_tx_0, ack_received]
- [open_modem_rx_0, pdu_out, pdu_to_text_0, pdu_in]
- [open_modem_rx_0, symbols_out, pdu_to_stream_1, pdus]
- [pdu_to_stream_1, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [open_modem_tx_0, audio_out, pdu_to_stream_0, pdus]
- [open_modem_tx_0, delivery_failed, blocks_message_debug_1, print]
- [open_modem_tx_0, ptt, blocks_message_debug_0, print]
- [pdu_to_stream_0, '0', blocks_add_xx_0, '0']
- [pdu_to_text_0, text, qtgui_edit_box_msg_1, val]
- [qtgui_edit_box_msg_0, msg, open_modem_tx_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
