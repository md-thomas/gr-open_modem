options:
  parameters:
    author: mdthomas
    category: '[open_modem]'
    comment: Same TX/noisy-channel/RX/ACK loop as open_modem_noisy_loopback.grc, but open_modem_rx_0 also publishes the symbols it actually demodulated (post carrier/timing recovery, truncated to the real frame - see that block's own 'symbols_out' docstring) through a QT GUI Constellation Sink. Drag the noise slider up and watch the clusters smear from tight points into a blur as the mode's own cliff approaches - the same thing apps/margin_sweep.py and open_modem_noisy_loopback.grc show as numbers, here as a picture, live.
    description: open_modem RX constellation, live noisy-channel demo
    generate_options: qt_gui
    id: open_modem_constellation
    output_language: python
    title: open_modem RX Constellation
  states: {}

blocks:
- name: noise_sigma
  id: variable_qtgui_range
  parameters:
    comment: Same noise standard deviation as open_modem_noisy_loopback.grc's --noise-sigma, but a live slider here instead of a command-line value - drag it up while watching the constellation below.
    gui_hint: 0,0,1,1
    label: Noise sigma
    start: '0'
    step: '0.02'
    stop: '2.0'
    value: '0.3'
  states: {}
- name: ack_responder_0
  id: open_modem_ack_responder
  parameters:
    comment: Turns open_modem_rx_0's ack_needed into a real ACK burst, fed back through the SAME noisy channel as open_modem_tx_0's own audio_out/ptt.
    dst_id: ALL
    fec_preset: ''
    mode_id: mode_id
    port: mic
    station_id: K0MDT
    tx_level: '0.7'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    comment: Gaussian noise added to the channel - standard deviation is the noise_sigma slider above.
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: The noisy channel itself - sums the clean audio burst stream with the Gaussian noise stream, continuously.
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Decoded frames (and bursts heard but not decoded, as noise increases) print here.
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: key/unkey events print here, from both open_modem_tx_0 and ack_responder_0.
  states: {}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters:
    comment: Fires if ack_max_retries is exceeded with no ACK heard back.
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Sends a fixed test message through the TX chain every 3 s.
    msg: pmt.intern("watch the constellation")
    period: '3000'
  states: {}
- name: mode_id
  id: parameter
  parameters:
    comment: The one Waveform Mode under test - open_modem_tx_0, open_modem_rx_0 and ack_responder_0 all reference this single value, not each its own copy (see open_modem_noisy_loopback.grc's own mode_id comment for why that matters - a mismatch fails outright, not just more often under noise).
    short_id: m
    type: intx
    value: '1'
  states: {}
- name: open_modem_rx_0
  id: open_modem_open_modem_rx
  parameters:
    comment: mode_ids is a single-element list referencing the shared mode_id parameter above, so it can never drift out of sync with open_modem_tx_0.
    fec_preset: ''
    max_burst_s: '6.0'
    mode_ids: '[mode_id]'
    port: mic
    sample_rate: '48000'
    threshold: '0.4'
  states: {}
- name: open_modem_tx_0
  id: open_modem_open_modem_tx
  parameters:
    ack_max_retries: '3'
    ack_requested: 'True'
    ack_timeout_s: '2.0'
    dst_id: ALL
    fec_preset: ''
    lead_in_s: '0.1'
    mode_id: mode_id
    port: mic
    station_id: K0MDT
    tail_s: '0.02'
    tx_level: '0.7'
  states: {}
- name: pdu_to_stream_0
  id: open_modem_pdu_to_stream
  parameters:
    comment: Drains open_modem_tx_0's (and ack_responder_0's) audio_out PDUs into a float stream a work() call at a time - see open_modem_loopback.grc's own top-level comment for why not the stock PDU to Tagged Stream block (that limitation is specific to the much larger audio-sample-rate stream, not the much smaller symbol-rate one below, which uses that stock block fine).
  states: {}
- name: pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Converts open_modem_rx_0's symbols_out PDU (demodulated complex symbols, truncated to the real frame) into a tagged complex stream for the Constellation Sink. The stock block's buffer limits (see TODO.md) only bite for audio-sample-rate PDUs - symbol counts per burst are hundreds to low thousands, well under that ceiling.
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Each point is one demodulated symbol. Tight clusters at the mode's ideal constellation points means a clean decode; a smeared ring or blob means noise_sigma is past (or near) this mode's cliff.
    grid: 'True'
    gui_hint: 1,0,1,1
    size: '1024'
    type: complex
  states: {}

connections:
- [ack_responder_0, audio_out, pdu_to_stream_0, pdus]
- [ack_responder_0, ptt, blocks_message_debug_1, print]
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', open_modem_rx_0, '0']
- [blocks_message_strobe_0, strobe, open_modem_tx_0, pdu_in]
- [open_modem_rx_0, ack_needed, ack_responder_0, ack_needed]
- [open_modem_rx_0, ack_received, open_modem_tx_0, ack_received]
- [open_modem_rx_0, pdu_out, blocks_message_debug_0, print]
- [open_modem_rx_0, symbols_out, pdu_to_tagged_stream_0, pdus]
- [open_modem_tx_0, audio_out, pdu_to_stream_0, pdus]
- [open_modem_tx_0, delivery_failed, blocks_message_debug_2, print]
- [open_modem_tx_0, ptt, blocks_message_debug_1, print]
- [pdu_to_stream_0, '0', blocks_add_xx_0, '0']
- [pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
